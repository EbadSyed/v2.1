<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ucos3_wifi_whiteboard.ewp</path>
  </project>

  <batchBuild/>
</workspace>
