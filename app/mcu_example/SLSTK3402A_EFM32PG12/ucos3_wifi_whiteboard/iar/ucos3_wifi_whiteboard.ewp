# IAR project ucos3_wifi_whiteboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\gpiointerrupt\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\platform\middleware\glib\glib; ..\..\..\..\..\platform\middleware\glib\dmd; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-CPU; ..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-LIB; ..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Source; ..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Trace\SystemView\Source; ..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Trace\SystemView\ThirdPartyLibrary\SEGGER; ..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..; ..\BSP; ..\Cfg; ..\WiFi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ucos3_wifi_whiteboard.bin
  ILINK.IlinkOutputFile: ucos3_wifi_whiteboard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group BSP
    ../BSP/: bsp_os.c cpu_bsp.c
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
    ../../../../../util/third_party/micrium/Ports/CMSIS/IAR/: cmsis_wrapper.s
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group emdrv
    ../../../../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group uC-CPU
    ../../../../../util/third_party/micrium/uCOS-III/uC-CPU/: cpu_core.c
    ../../../../../util/third_party/micrium/uCOS-III/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
  group uC-LIB
    ../../../../../util/third_party/micrium/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-III
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Trace/SystemView/ThirdPartyLibrary/Sample/OS/: SEGGER_SYSVIEW_uCOSIII.c
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Trace/SystemView/ThirdPartyLibrary/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu_c.c os_cpu_a.asm
  group Source
    ../: app_lcd.c app_uart.c app_wifi.c app.c app_os_hooks.c main.c
