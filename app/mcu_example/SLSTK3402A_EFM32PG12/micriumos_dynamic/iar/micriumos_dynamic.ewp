# IAR project micriumos_dynamic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\sleep\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..\..\..\..\..\util\micrium\Micrium_OS; ..\..\..\..\..\util\micrium\Micrium_OS\bsp\siliconlabs\generic\include; ..\cfg; ..; ..\..\..\..\..\util\micrium\Tools\SystemView\SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: micriumos_dynamic.bin
  ILINK.IlinkOutputFile: micriumos_dynamic.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
    ../../../../../util/micrium/Ports/CMSIS/IAR/: cmsis_wrapper.s
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../util/micrium/Micrium_OS/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c bsp_tick_rtcc.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
    ../../../../../platform/emdrv/sleep/src/: sleep.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_core.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_rmu.c em_rtcc.c em_system.c em_usart.c
  group common
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/auth/: auth.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/clk/: clk.c clk_cmd.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/common/: common.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/kal/: kal_kernel.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/rtos/: rtos_err_str.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/platform_mgr/: platform_mgr.c
  group cpu
    ../../../../../util/micrium/Micrium_OS/rtos/cpu/source/: cpu_core.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/iar/: armv7m_cpu_a.asm armv7m_cpu_c.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/generic/: armv7m_cpu_int.c
  group kernel
    ../../../../../util/micrium/Micrium_OS/rtos/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/iar/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group SystemView
    ../../../../../util/micrium/Tools/SystemView/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../../util/micrium/Tools/SystemView/Sample/OS/: SEGGER_SYSVIEW_MicriumOSKernel.c
    ../cfg/: SEGGER_SYSVIEW_Config_MicriumOSKernel.c
  group Source
    ../: ex_main.c
    ../common/common/: ex_common_init.c
