# IAR project micriumos_webmic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192; DEBUG_EFM; RETARGET_VCOM; HAVE_CONFIG_H
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\dmadrv\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\..\..\util\micrium\Micrium_OS; ..\..\..\..\..\util\micrium\Micrium_OS\bsp\siliconlabs\generic\include; ..\..\..\..\..\util\micrium\Ports; ..\cfg; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\platform\middleware\glib\glib; ..\..\..\..\..\platform\middleware\glib\dmd; ..; ..\libs\include; ..\..\..\..\..\util\micrium\Tools\SystemView\SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: micriumos_webmic.bin
  ILINK.IlinkOutputFile: micriumos_webmic.out
  ILINK.IlinkIcfFile: ..\micriumos_webmic.icf
  ILINK.IlinkAdditionalLibs: ..\libs\libopus_iar.a; ..\libs\libogg_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192; DEBUG_EFM; RETARGET_VCOM; HAVE_CONFIG_H
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
    ../../../../../util/micrium/Ports/CMSIS/IAR/: cmsis_wrapper.s
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_stk_leds.c bsp_trace.c
    ../../../../../util/micrium/Micrium_OS/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c bsp_net_ether_gem.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_core.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c em_prs.c em_rtcc.c em_ldma.c
  group common
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/collections/: bitmap.c slist.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/common/: common.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/kal/: kal_kernel.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/platform_mgr/: platform_mgr.c
  group cpu
    ../../../../../util/micrium/Micrium_OS/rtos/cpu/source/: cpu_core.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/iar/: armv7m_cpu_a.asm armv7m_cpu_c.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/generic/: armv7m_cpu_int.c
  group drivers
    ../../../../../util/micrium/Micrium_OS/rtos/drivers/net/source/: net_drv_ether_gem.c net_drv_phy_generic.c
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c display.c displayls013b7dh06.c displaypalemlib.c udelay.c
    ../../../../../platform/emdrv/dmadrv/inc/: dmadrv.h
    ../../../../../platform/emdrv/dmadrv/src/: dmadrv.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_string.c glib_line.c glib_rectangle.c glib_font_normal_8x8.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group kernel
    ../../../../../util/micrium/Micrium_OS/rtos/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_msg.c os_mutex.c os_prio.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/iar/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group net
    ../../../../../util/micrium/Micrium_OS/rtos/net/source/tcpip/: net.c net_app.c net_arp.c net_ascii.c net_bsd.c net_buf.c net_cache.c net_conn.c net_ctr.c net_icmp.c net_icmpv4.c net_icmpv6.c net_if.c net_if_802x.c net_if_ether.c net_ip.c net_ipv4.c net_ipv6.c net_mldp.c net_ndp.c net_sock.c net_stat.c net_task.c net_tcp.c net_tmr.c net_udp.c net_util.c
    ../../../../../util/micrium/Micrium_OS/rtos/net/source/util/: net_svc_task.c
    ../../../../../util/micrium/Micrium_OS/rtos/net/source/dhcp/: dhcp_client.c
    ../../../../../util/micrium/Micrium_OS/rtos/net/source/dns/: dns_client.c dns_client_cache.c dns_client_req.c dns_client_task.c
  group mic
    ../mic/: mic_config.h mic_i2s.h mic_i2s.c
  group SystemView
    ../../../../../util/micrium/Tools/SystemView/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../../util/micrium/Tools/SystemView/Sample/OS/: SEGGER_SYSVIEW_MicriumOSKernel.c
    ../cfg/: SEGGER_SYSVIEW_Config_MicriumOSKernel.c
  group Source
    ../: main.c graphics.c common_declarations.h displayconfigapp.h
    ../net/core/: net_core.c
    ../net/http/: http_server_no_fs.c http_server_init.c
  group http
    ../../../../../util/micrium/Micrium_OS/rtos/net/source/http/: http.c http_dict.c
    ../../../../../util/micrium/Micrium_OS/rtos/net/source/http/server/: http_server.c http_server_conn.c http_server_mem.c http_server_priv.h http_server_req.c http_server_resp.c http_server_sock.c http_server_str.c http_server_task.c
