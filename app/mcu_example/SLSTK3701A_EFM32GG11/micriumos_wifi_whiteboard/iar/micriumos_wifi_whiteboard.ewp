# IAR project micriumos_wifi_whiteboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\gpiointerrupt\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\platform\middleware\glib\glib; ..\..\..\..\..\platform\middleware\glib\dmd; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\..\..\util\micrium\Micrium_OS; ..\..\..\..\..\util\micrium\Micrium_OS\bsp\siliconlabs\generic\include; ..; ..\BSP; ..\Cfg; ..\WiFi; ..\..\..\..\..\util\micrium\Tools\SystemView\SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32GG11B820F2048GL192; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: micriumos_wifi_whiteboard.bin
  ILINK.IlinkOutputFile: micriumos_wifi_whiteboard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../util/micrium/Micrium_OS/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
    ../../../../../util/micrium/Ports/CMSIS/IAR/: cmsis_wrapper.s
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh06.c displaypalemlib.c udelay.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group emdrv
    ../../../../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group Common
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/auth/: auth.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/clk/: clk.c clk_cmd.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/common/: common.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/kal/: kal_kernel.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/rtos/: rtos_err_str.c
    ../../../../../util/micrium/Micrium_OS/rtos/common/source/platform_mgr/: platform_mgr.c
  group CPU
    ../../../../../util/micrium/Micrium_OS/rtos/cpu/source/: cpu_core.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/iar/: armv7m_cpu_a.asm armv7m_cpu_c.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/generic/: armv7m_cpu_int.c
  group Kernel
    ../../../../../util/micrium/Micrium_OS/rtos/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../util/micrium/Micrium_OS/rtos/ports/source/iar/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group SystemView
    ../../../../../util/micrium/Tools/SystemView/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../../util/micrium/Tools/SystemView/Sample/OS/: SEGGER_SYSVIEW_MicriumOSKernel.c
    ../Cfg/: SEGGER_SYSVIEW_Config_MicriumOSKernel.c
  group Source
    ../: app_lcd.c app_uart.c app_wifi.c app.c main.c
