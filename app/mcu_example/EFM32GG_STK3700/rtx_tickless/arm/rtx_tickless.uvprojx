# Keil uVision project rtx_tickless.uvprojx, settings and files
target rtx_tickless (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: rtx_tickless
  AfterMake: fromelf.exe --bin --output obj\rtx_tickless.bin obj\rtx_tickless.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\util\third_party\keil_rtx\Inc;..\..\..\..\..\hardware\kit\EFM32GG_STK3700\config
  asm define: EFM32GG990F1024
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_rtc.c em_system.c
  group Source
    ../: rtx_tickless.c RTX_Conf_CM.c
  group Libraries
    ../../../../../util/third_party/keil_rtx/LIB/ARM/: RTX_CM3.lib
