# IAR project serial-uart-ota-bootloader.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="../../platform/base/hal/micro/cortexm3/em35x/board/dev0680_21gpio.h"; PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EM3555; PHY_EM3XX; BOARD_BREAKOUT_BOARD; CORTEXM3_EMBER_MICRO; BTL_HAS_RADIO; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_SERIAL_UART_OTA; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\..\..\platform\base\HAL\; ..\..\..\..\..\platform\base\; ../../../../../platform/CMSIS/Include; ../../../../../platform/Device/SiliconLabs/em355x/Include/; ../../../../../platform/base/hal/micro/cortexm3/common; ../../../../../platform/base/hal/plugin; ../../../app/util; ../../../../../platform/base/lwip/; ../../../../../platform/base/lwip/src/include/; ../../../../../platform/base/lwip/contrib/port/FreeRTOS/EM358X/; ../../../../../platform/base/lwip/src/include/ipv4/; ../../../../../platform/base/lwip/src/include/ipv6/; ../../../app/test/micrium_cfg/; ../../../../../util/third_party/micrium/MicriumOS/; ../../../../../util/third_party/micrium/MicriumOS/rtos/common/include/; ../../../../../util/third_party/micrium/MicriumOS/rtos/kernel/include/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="../../platform/base/hal/micro/cortexm3/em35x/board/dev0680_21gpio.h"; PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EM3555; PHY_EM3XX; BOARD_BREAKOUT_BOARD; CORTEXM3_EMBER_MICRO; BTL_HAS_RADIO; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_SERIAL_UART_OTA
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: serial-uart-ota-bootloader.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: serial-uart-ota-bootloader.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1; FLASH_SIZE=1M; RAM_SIZE=256K
  ILINK.IlinkIcfFile: ../../../../../platform/base/hal/micro/cortexm3/em35x/em3555/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../../platform/base/hal/micro/cortexm3/bootloader/: bootloader-gpio.c bootloader-uart.c cstartup-iar-boot-entry.s79 cstartup-iar-boot.c
    ../../../build/bootloader-phy-library-cortexm3-iarboot-em3555-em3xx/: bootloader-phy-library.a
    ../../../../../platform/base/hal/micro/generic/: crc.c mem-util.c random.c
    ../../../../../platform/base/hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../../../platform/base/hal/micro/cortexm3/common/: standalone-bootloader-custom.c
    ../../../build/standalone-bootloader-library-cortexm3-iarboot-em3555-em3xx/: standalone-bootloader-library.a
